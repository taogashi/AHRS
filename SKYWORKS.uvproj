# Keil uVision project SKYWORKS.uvproj, settings and files
target 1.LED (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SKYWORKS +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,ARM_MATH_CM3
  c include: ..\CMSIS;..\StdPeriph_Driver\inc;..\User;..\Source\include;..\Source\portable\RVDS\ARM_CM3;..\DSP_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c
    ./: ledTask.c AHRS.c AHRSEKF.c axisTrans.c filter.c flashTask.c kalman.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_dma.c
  group StartUp
    ../StartUp/: startup_stm32f10x_md.s
  group FreeRTOS Files
    ../Source/: croutine.c list.c queue.c tasks.c timers.c freeRTOSinSkyworks.txt
    ../Source/portable/RVDS/ARM_CM3/: port.c
    ../Source/portable/MemMang/: heap_2.c
  group UserPeriph
    ../User/: led.c
    ./: I2C.c ITG3200.c LIS3LV02DQ.c LSM303DLH.c spi.c
  group arm_math
    ../DSP_lib/: arm_mat_add_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c arm_cos_f32.c arm_sin_f32.c
